# IAR project SieAmp.ewp, settings and files
configuration ELKA (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\SieAmp\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ELKA_LOG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LOG
  group (top)
    ./: conf_loader.c config_data.c file_works.c font.c func.asm gui.c inc.c main.c menu_module.h Skin.c unpack.c
  group medialibs
    medialibs/: audio.c audio.h id3lib.c id3lib.h ImageUtils.c ImageUtils.h m3uparse.c m3uparse.h
